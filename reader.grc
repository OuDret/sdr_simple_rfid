options:
  parameters:
    author: OuDret
    generate_options: qt_gui
    id: reader
    output_language: python
    title: RFID reader
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '2.5'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 15.56e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/joan/Desktop/gnu_radio_rfid_ask/tag_signal.txt
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
